# IAR project helloworld.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F4XX
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: C:\Users\larry\Documents\STM32F4Example\stm32_discovery_arm_gcc-master\STM32F4-Discovery_FW_V1.1.0\Utilities\STM32F4-Discovery; C:\Users\larry\Documents\STM32F4Example\stm32_discovery_arm_gcc-master\STM32F4-Discovery_FW_V1.1.0\Libraries\STM32F4xx_StdPeriph_Driver\inc; C:\Users\larry\Documents\STM32F4Example\stm32_discovery_arm_gcc-master\STM32F4-Discovery_FW_V1.1.0\Libraries\CMSIS\Include; C:\Users\larry\Documents\STM32F4Example\stm32_discovery_arm_gcc-master\STM32F4-Discovery_FW_V1.1.0\Libraries\CMSIS\ST\STM32F4xx\Include; $PROJ_DIR$; inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  ILINK.IlinkOutputFile: cpp.out
  ILINK.IlinkIcfFile: helloworld.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../../C/: main.ENU.projtempl
  group EWARM
    ../../stm32_discovery_arm_gcc-master/STM32F4-Discovery_FW_V1.1.0/Libraries/CMSIS/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f4xx.s
  group STM32F4-Discovery
    ../../stm32_discovery_arm_gcc-master/STM32F4-Discovery_FW_V1.1.0/Utilities/STM32F4-Discovery/: stm32f4_discovery.c
  group STM32F4xx_StdPeriph_Driver
    ../../stm32_discovery_arm_gcc-master/STM32F4-Discovery_FW_V1.1.0/Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c
    src/: sccb.c
  group User
    src/: application.c camera_api.c dcmi_ov2640.c ring_buffer.c serial_interface.c
    ./: main.cpp stm32f4xx_it.c system_stm32f4xx.c
